## tests/sleep_scheduler_test/testcase.yaml
```yaml
tests:
  sleep_scheduler.test:
    platform_allow: nrf52840dk/nrf52840
    tags: sleep_scheduler
    harness: ztest
    timeout: 300
```
